# Keil uVision project test_vl53l8cx.uvprojx, settings and files
target test_vl53l8cx (6220000::V6.22::ARMCLANG)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: test_vl53l8cx +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../TOF/App;../TOF/Target;../Drivers/BSP/custom;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/Common;../Drivers/BSP/53L8A1;../Drivers/BSP/Components/vl53l8cx/modules;../Drivers/BSP/Components/vl53l8cx/porting;../Drivers/BSP/Components/vl53l8cx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c bsp.c dma.c usart.c custom_bus.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Application/User/TOF/App
    ../TOF/App/: app_tof.c
  group Drivers/BSP/custom
    ../Drivers/BSP/custom/: custom.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/vl53l8cx/modules/: vl53l8cx_api.c vl53l8cx_plugin_detection_thresholds.c vl53l8cx_plugin_motion_indicator.c vl53l8cx_plugin_xtalk.c
    ../Drivers/BSP/Components/vl53l8cx/porting/: platform.c
    ../Drivers/BSP/Components/vl53l8cx/: vl53l8cx.c
  group Drivers/BSP/53L8A1
    ../Drivers/BSP/53L8A1/: 53l8a1_ranging_sensor.c
  group Middlewares/X-CUBE-TOF1/Documentation
    ../Drivers/BSP/53L8A1/: LICENSE.txt
    ../Drivers/BSP/Components/vl53l8cx/: LICENSE.txt
software components: CMSIS:CORE 6.1.0
